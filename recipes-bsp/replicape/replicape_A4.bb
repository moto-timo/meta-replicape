include replicape.inc

S = "${WORKDIR}/Replicape/"

inherit setuptools


