SUMMARY = "Replicape is a 3D printer cape for BeagleBone"
DESCRIPTION = "Software written in Python for maintainability and hackability. \
\
Software features: \
- Accelleration with corner speed prediction. \
- Printer settings loaded from file (Version 0.4.2) \
- Controllable via ethernet, USB, printer display. \
"
LICENSE="BSD"

SRC_URI = "git://bitbucket.org/intelligentagent/replicape.git;protocol=https"



