IMAGE_INSTALL += " \
    pasm \
    pypruss \
    redeem \
    toggle \
    tty0tty \   
    cura \
    octoprint \
    kernel-module-bb-sgx \
    bb-sgx \
    bb-sgx-dev \
    nano \
    replicape-device-tree \
    python-numpy \
    kernel-module-uio-pruss \
    ntpdate \
"

export IMAGE_BASENAME = "systemd-thing-image"

